FILESEXTRAPATHS_prepend_hs2500 := "${THISDIR}/${PN}:"
