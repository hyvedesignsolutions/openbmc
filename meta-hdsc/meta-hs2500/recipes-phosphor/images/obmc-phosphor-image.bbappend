OBMC_IMAGE_EXTRA_INSTALL_append_romulus = " mboxd liberation-fonts uart-render-controller"
OBMC_IMAGE_EXTRA_INSTALL_append_hs2500 = " lamp-test fan-test"
