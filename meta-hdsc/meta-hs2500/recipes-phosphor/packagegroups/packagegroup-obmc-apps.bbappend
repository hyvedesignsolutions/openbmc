RDEPENDS_${PN}-inventory_append_romulus = " openpower-occ-control phosphor-cooling-type id-button"
RDEPENDS_${PN}-extras_append_hs2500 = " phosphor-webui phosphor-image-signing"
