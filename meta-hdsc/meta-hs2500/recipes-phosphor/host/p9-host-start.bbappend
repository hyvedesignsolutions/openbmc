RDEPENDS_${PN}_append_hs2500 = " avsbus-control"
RDEPENDS_${PN}_append_hs2500 = " vrm-control"
RDEPENDS_${PN}_remove_hs2500 = "p9-vcs-workaround"
