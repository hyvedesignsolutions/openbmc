RDEPENDS_${PN}-chassis_remove_hs2500 = " op-fsi \
                                         p9-cfam-override \
                                        "