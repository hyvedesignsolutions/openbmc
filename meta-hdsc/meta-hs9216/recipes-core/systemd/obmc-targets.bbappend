FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

CHASSIS_ACTION_TARGETS += "reset"
