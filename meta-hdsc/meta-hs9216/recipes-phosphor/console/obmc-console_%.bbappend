FILESEXTRAPATHS_prepend_hs9216 := "${THISDIR}/${PN}:"
OBMC_CONSOLE_HOST_TTY = "ttyS2"
