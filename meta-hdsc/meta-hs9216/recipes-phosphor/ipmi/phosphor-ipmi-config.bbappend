FILESEXTRAPATHS_prepend_hs9216 := "${THISDIR}/${PN}:"
